## config/boards/shields/artsyfartsy/Kconfig.defconfig
```kconfig
# SPDX-License-Identifier: MIT

if SHIELD_ARTSYFARTSY

config ZMK_KEYBOARD_NAME
    default "artsyfartsy"

endif
```
